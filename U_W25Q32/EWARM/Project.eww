<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\U_W25Q32.ewp</path>
  </project>
  <batchBuild />
</workspace>
